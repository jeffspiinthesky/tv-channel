options:
  parameters:
    category: Custom
    description: DVB-T transmit, 2K/QPSK/CR1-2/GI1-4, fed from a local UDP relay (see relay-to-hackrf.sh) instead of a file, driving a HackRF via SoapySDR.
    generate_options: no_gui
    id: dvbt_tx_2k_qpsk_8mhz_test
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: DVB-T TX (2K, QPSK, CR1/2, GI1/4)
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 610e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: TEST -- back to 8MHz to re-check now that the receiver-side firmware bug is fixed. Originally dropped to 6MHz because the Pi 4 couldn't sustain 8MHz's 9.14MS/s even with real-time scheduling -- that finding was about the transmit side's raw CPU/USB throughput, not the receiver, so it should still apply unchanged. Worth re-testing rather than assuming.
    value: (8000000.0 * 8) / 7
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: udp_port
  id: variable
  parameters:
    comment: relay-to-hackrf.sh listens on ffplayout's multicast feed and re-emits a null-padded, rate-regulated TS on this local port.
    value: '6000'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: Local relay output, NOT ffplayout's multicast address directly -- this block has no multicast-join support.
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: '1316'
    port: udp_port
    src_zeros: 'False'
    type: byte
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: cp_len = 2048 / 4 (GI 1/4 at 2K FFT). maxoutbuf bumped from default so osmosdr_sink_0 has a bigger cushion to ride out RR scheduling contention among the flowgraph's other equal-priority RT threads (see video-script.md 8MHz-underrun diagnosis).
    cp_len: '512'
    input_size: '2048'
    maxoutbuf: '1000000'
    tagname: ''
  states: {}
- name: dtv_dvbt_bit_inner_interleaver_0
  id: dtv_dvbt_bit_inner_interleaver
  parameters:
    constellation: qpsk
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_energy_dispersal_0
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C1_2
    constellation: qpsk
    hierarchy: nh
    ninput: '1'
    noutput: '1512'
  states: {}
- name: dtv_dvbt_map_0
  id: dtv_dvbt_map
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reference_signals_0
  id: dtv_dvbt_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C1_2
    code_rate_lp: C1_2
    constellation: qpsk
    guard_interval: GI_1_4
    hierarchy: nh
    include_cell_id: call_id_yes
    transmission_mode: T2k
    type: complex
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Interleave
    transmission_mode: T2k
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    affinity: '3'
    bb_gain0: '20'
    bw0: '8000000'
    comment: HackRF via libhackrf directly -- unlike the packaged SoapyHackRF module, this accepts the exact fractional 64/7 MS/s DVB-T rate. Pinned to core 3 so it never has to round-robin-wait behind the other equal-priority RT threads for CPU time (see video-script.md 8MHz-underrun diagnosis).
    freq0: center_freq
    gain0: tx_gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
  states: {}

connections:
- [network_udp_source_0, '0', dtv_dvbt_energy_dispersal_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', osmosdr_sink_0, '0']
- [dtv_dvbt_bit_inner_interleaver_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', dtv_dvbt_inner_coder_0, '0']
- [dtv_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [dtv_dvbt_inner_coder_0, '0', dtv_dvbt_bit_inner_interleaver_0, '0']
- [dtv_dvbt_map_0, '0', dtv_dvbt_reference_signals_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [dtv_dvbt_reference_signals_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_map_0, '0']

metadata:
  file_format: 1
