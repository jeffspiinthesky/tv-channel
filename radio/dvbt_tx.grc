options:
  parameters:
    category: Custom
    description: DVB-T transmit, 2K/QPSK/CR1-2/GI1-4, fed from a local UDP relay (see relay_to_hackrf.py) instead of a file, driving a HackRF via SoapySDR. Bandwidth/frequency/gain/UDP port/datagram-batch-size are all runtime parameters -- see the CLI flags this generates -- so one flowgraph covers any DVB-T bandwidth instead of maintaining a separate file per bandwidth.
    generate_options: no_gui
    id: dvbt_tx
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: DVB-T TX (2K, QPSK, CR1/2, GI1/4)
  states: {}

blocks:
- name: bandwidth_hz
  id: parameter
  parameters:
    comment: Must match your country's real DVB-T bandwidth. UK/most-of-Europe standard is 8000000 -- this project's default, validated end-to-end (GNU Radio -> HackRF -> a real TV). Only use 6000000/7000000 if your own country's terrestrial standard genuinely uses it -- see README.
    label: Bandwidth (Hz)
    short_id: b
    type: intx
    value: '8000000'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center frequency (Hz)
    short_id: f
    type: eng_float
    value: 610e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample clock scales linearly with bandwidth for this fixed 2K/QPSK/CR1-2/GI1-4 profile -- only bandwidth_hz needs to change to retune bandwidth.
    value: (bandwidth_hz * 8) / 7
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: TX gain (dB)
    short_id: g
    type: intx
    value: '40'
  states: {}
- name: udp_port
  id: parameter
  parameters:
    comment: relay_to_hackrf.py listens on ffplayout's multicast feed and re-emits a null-padded, rate-regulated TS on this local port. Must match the relay's --dst-port.
    label: UDP listen port
    short_id: u
    type: intx
    value: '6000'
  states: {}
- name: packets_per_datagram
  id: parameter
  parameters:
    comment: Must match the relay's --packets-per-datagram exactly -- GNU Radio's network_udp_source requires the sender's datagram size and this payload size to match exactly. Bisected 2026-09-19 -- 7 packets/1316 bytes underruns continuously at 8MHz forever; the cliff to clean, stable operation is 34-35 packets/~6.4-6.6KB; 40 gives real margin. Raise this if a different bandwidth/hardware combination underruns.
    label: Packets per relay datagram
    short_id: p
    type: intx
    value: '40'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: Local relay output, NOT ffplayout's multicast address directly -- this block has no multicast-join support.
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: packets_per_datagram * 188
    port: udp_port
    src_zeros: 'False'
    type: byte
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: cp_len = 2048 / 4 (GI 1/4 at 2K FFT). maxoutbuf bumped from default so osmosdr_sink_0 has a bigger cushion to ride out RR scheduling contention among the flowgraph's other equal-priority RT threads (see video-script.md 8MHz-underrun diagnosis).
    cp_len: '512'
    input_size: '2048'
    maxoutbuf: '1000000'
    tagname: ''
  states: {}
- name: dtv_dvbt_bit_inner_interleaver_0
  id: dtv_dvbt_bit_inner_interleaver
  parameters:
    constellation: qpsk
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_energy_dispersal_0
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C1_2
    constellation: qpsk
    hierarchy: nh
    ninput: '1'
    noutput: '1512'
  states: {}
- name: dtv_dvbt_map_0
  id: dtv_dvbt_map
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reference_signals_0
  id: dtv_dvbt_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C1_2
    code_rate_lp: C1_2
    constellation: qpsk
    guard_interval: GI_1_4
    hierarchy: nh
    include_cell_id: call_id_yes
    transmission_mode: T2k
    type: complex
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Interleave
    transmission_mode: T2k
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    affinity: '3'
    bb_gain0: '20'
    bw0: bandwidth_hz
    comment: HackRF via libhackrf directly -- unlike the packaged SoapyHackRF module, this accepts the exact fractional 64/7 MS/s DVB-T rate. Pinned to core 3 so it never has to round-robin-wait behind the other equal-priority RT threads for CPU time (see video-script.md 8MHz-underrun diagnosis). Kept unconditional across all bandwidths -- it doesn't hurt lower bandwidths.
    freq0: center_freq
    gain0: tx_gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
  states: {}

connections:
- [network_udp_source_0, '0', dtv_dvbt_energy_dispersal_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', osmosdr_sink_0, '0']
- [dtv_dvbt_bit_inner_interleaver_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', dtv_dvbt_inner_coder_0, '0']
- [dtv_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [dtv_dvbt_inner_coder_0, '0', dtv_dvbt_bit_inner_interleaver_0, '0']
- [dtv_dvbt_map_0, '0', dtv_dvbt_reference_signals_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [dtv_dvbt_reference_signals_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_map_0, '0']

metadata:
  file_format: 1
